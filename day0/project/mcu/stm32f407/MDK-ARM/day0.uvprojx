# Keil uVision project day0.uvprojx, settings and files
target day0 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  group app
    ../../../app/: control.c motor_monitor.c
